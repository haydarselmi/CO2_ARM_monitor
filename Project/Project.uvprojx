# Keil uVision project Project.uvprojx, settings and files
target Open1786 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\Libraries\LCP1768_StdPeriph_Driver\include;..\Libraries\CM3\CoreSupport;..\Libraries\CM3\DeviceSupport\NXP\LPC17xx;..\User
  asm define: __BUILD_WITH_EXAMPLE__=1,__RAM_MODE__=0
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ../Libraries/CM3/DeviceSupport/NXP/LPC17xx/startup/arm/: startup_LPC17xx.s
  group CMSIS-CM3
    ../Libraries/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
    ../Libraries/CM3/CoreSupport/: core_cm3.c
  group StdPeriph_Driver
    ../Libraries/LCP1768_StdPeriph_Driver/source/: lpc17xx_clkpwr.c lpc17xx_gpio.c lpc17xx_pinsel.c lpc17xx_timer.c lpc17xx_exti.c lpc17xx_nvic.c lpc17xx_ssp.c lpc17xx_i2c.c lpc17xx_uart.c
  group User
    ../User/: main.c affichagelcd.c globaldecimport.h bluetooth.h son.c son.h adc.c adc.h bluetoothCommands.c annexes.c annexes.h bluetoothCommands.h globaldec.h affichagelcd.h timers.c timers.h pinconfig.c pinconfig.h co2_sensor.c co2_sensor.h
    ../User/touch/: ili_lcd_general.c lcd_api.c english_16x8.c
    ./: bluetoothConf.c
    ../Libraries/LCP1768_StdPeriph_Driver/include/: lpc17xx_adc.h
    ../Libraries/LCP1768_StdPeriph_Driver/source/: lpc17xx_adc.c
software components: CMSIS:CORE 5.5.0
